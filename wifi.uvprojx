# Keil uVision project wifi.uvprojx, settings and files
target wifi (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wifi
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\CMSIS;.\CMSIS\startup;.\FWlib\inc;.\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group FWLIB
    ./FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ./USER/: client.c main.c stm32f10x_it.c systick.c TIME2.c USART3.c USART2.c USART1.c Hardware.h stm32f10x_conf.h beep.c main.h delay.c usart2printf.c
